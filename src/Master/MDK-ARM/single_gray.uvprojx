# Keil uVision project single_gray.uvprojx, settings and files
target signal_gray (::::)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: single_gray
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Core\Inc;.\User\Inc;..\Drivers\CW32L010_HAL_Driver\Inc;.\Control\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x2800 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Application/MDK-ARM
    ./: startup_cw32l010.s
    ../Core/Src/: system_cw32l010.c
  group Application/User/Core
    ../Core/Src/: cw32l010_sysctrl.c cw32l010_gpio.c cw32l010_flash.c cw32l010_systick.c cw32l010_uart.c cw32l010_atim.c cw32l010_gtim.c cw32l010_adc.c cw32l010_i2c.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/CW32L010_HAL_Driver/Src/: cw32l010_hal_gpio.c
  group User
    ./User/Src/: interrupts_cw32l010.c main.c gpio.c uart.c time.c adc.c flash.c i2c.c
  group Control
    ./Control/Src/: control.c light.c myMath.c sys_config_and_flash.c binary.c gray.c register.c color2.c
software components: CMSIS:CORE 5.6.0
